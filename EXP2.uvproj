# Keil uVision project EXP2.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: EXP2
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LCD.c main.c UART.c Util.c LCD.h UART.h Util.h SPI.c SPI.h SD.c SD.h
    ./Exp_1_Fall_2018/: Long_Serial_In.c memory_test.c print_bytes.c AT89C51RC2.h Long_Serial_In.h Main.h memory_test.h PORT.H print_bytes.h
